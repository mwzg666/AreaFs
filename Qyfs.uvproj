# Keil uVision project Qyfs.uvproj, settings and files
target QYFSProbe (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group USER
    ./: ISR.asm main.c
    ./Uart/: uart.c
  group BSP
    ./Ads1110/: ads1110.c
    ./Flash/: EepRom.c
    ./IIC/: i2c.c
    ./Lcd/: Lcd.c LcdApp.c
    ./mcp4725/: mcp4725.c
    ./ModBus/: ModBus.c ModBusDev.c ModBusHost.c
    ./BSP/: system.c
    ./Probe/: PD_Probe.c CalcDoseRate.c Sensor.c
    ./MwPro/: cmd.c
